<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Devices\Connector.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Devices\HumitureDetection.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Devices\SolenoidValve.ewp</path>
  </project>
  <batchBuild/>
</workspace>


