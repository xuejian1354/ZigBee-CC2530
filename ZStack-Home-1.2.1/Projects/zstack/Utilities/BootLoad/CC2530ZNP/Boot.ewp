# IAR project Boot.ewp, settings and files
configuration CC2530ZNP Boot Loader (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: HAL_SB_BOOT_CODE; HAL_UART_SPI=2; LOCK_THE_BOOT_IMAGE_PAGES_IN_HEX_FILE; SBL_WAIT_TIME=60; NO_WD_RESET_FOR_BOOTLOADER
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\Source; source; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\_COMMON\CC2530; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530ZNP; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; $PROJ_DIR$
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: sb-boot_v2.xcl
  group App
    ../../../../../COMPONENTS/osal/include/: comdef.h
    ../Source/: sb_exec_v2.c sb_exec_v2.h
    source/: sb_main.c sb_main.h
  group HAL/Include
    ../../../../../COMPONENTS/hal/include/: hal_defs.h hal_flash.h hal_uart.h
  group HAL/Target/CC2530ZNP/Config
    ../../../../../Components/hal/target/CC2530ZNP/: hal_board_cfg.h
  group HAL/Target/CC2530ZNP/Drivers
    ../../../../../Components/hal/target/CC2530ZNP/: hal_flash.c
  group HAL/Target/CC2530ZNP/Includes
    ../../../../../Components/hal/target/CC2530ZNP/: hal_dma.h hal_mcu.h hal_types.h
  group Tools
    source/: interrupt_stubs.s51
    ../../../Tools/CC2530DB/: sb-boot_v2.xcl
