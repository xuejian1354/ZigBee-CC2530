# IAR project Boot.ewp, settings and files
configuration CC2531 Boot Loader (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2531F256.i51
  ICC8051.CCDefines: FEATURE_GREEN_POWER; FEATURE_ENHANCED_BEACON; HAL_SB_BOOT_CODE; SBL_WAIT_TIME=60; LOCK_THE_BOOT_IMAGE_PAGES_IN_HEX_FILE; NO_WD_RESET_FOR_BOOTLOADER
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\Source; source; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\_COMMON\CC2530; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530USB; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530USB\usb\library; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530USB\usb\library\cc2531; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530USB\usb\class_cdc; $PROJ_DIR$
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: sb-boot_v2.xcl
  group App
    ../Source/: sb_exec_v2.c sb_exec_v2.h
    source/: sb_main.c sb_main.h
  group HAL/Include
    ../../../../../COMPONENTS/hal/include/: hal_defs.h hal_flash.h hal_uart.h
  group HAL/Target/CC2530USB/Config
    ../../../../../COMPONENTS/hal/target/CC2530USB/: hal_board_cfg.h
  group HAL/Target/CC2530USB/Drivers
    ../../../../../Components/hal/target/CC2530USB/: hal_flash.c
  group HAL/Target/CC2530USB/Includes
    ../../../../../COMPONENTS/hal/target/CC2530USB/: hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2530USB/USB/class_cdc
    ../../../../../Components/hal/target/CC2530USB/usb/class_cdc/: usb_cdc.h usb_cdc_descriptor.s51 usb_cdc_hooks.c usb_cdc_hooks.h usb_firmware_library_config.c
    ../../../../../COMPONENTS/hal/target/CC2530USB/usb/class_cdc/: usb_firmware_library_config.h usb_firmware_library_headers.h
  group HAL/Target/CC2530USB/USB/library
    ../../../../../COMPONENTS/hal/target/CC2530USB/usb/library/: usb_descriptor.h usb_descriptor_parser.h usb_framework.h usb_framework_structs.h usb_interrupt.h usb_reg.h usb_standard_requests.h usb_suspend.h
    ../../../../../Components/hal/target/CC2530USB/usb/library/: usb_descriptor_parser.c usb_framework.c usb_standard_requests.c
  group HAL/Target/CC2530USB/USB/library/cc2531
    ../../../../../COMPONENTS/hal/target/CC2530USB/usb/library/cc2531/: usb_board_cfg.h
    ../../../../../Components/hal/target/CC2530USB/usb/library/cc2531/: usb_interrupt.c usb_suspend.c
  group Tools
    source/: interrupt_stubs.s51
    ../../../Tools/CC2530DB/: sb-boot_v2.xcl
